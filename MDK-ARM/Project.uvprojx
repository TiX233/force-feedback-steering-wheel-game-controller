# Keil uVision project Project.uvprojx, settings and files
target Project (6220000::V6.22::ARMCLANG)
  device: PY32F403xD Puya
  pack: Puya.PY32F4xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,PY32F403xD
  c include: ..\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PUYA\PY32F4xx\Include;..\Drivers\PY32F4xx_HAL_Driver\Inc;..\Middlewares\Third_Party\CherryUSB\port;..\Middlewares\Third_Party\CherryUSB\core;..\Middlewares\Third_Party\CherryUSB\common;..\Middlewares\Third_Party\CherryUSB\class\cdc;..\Middlewares\Third_Party\CherryUSB\class\hid;..\ltx\inc;..\ltx\components\app;..\ltx\components\debug;..\ltx\components\event_group;..\ltx\components\lock;..\ltx\components\log;..\ltx\components\script;..\ltx\drivers\bldc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Common
    ./: startup_py32f403xx.s
    ../Src/: system_py32f4xx.c
  group Application/User
    ../Src/: main.c py32f4xx_hal_msp.c py32f4xx_it.c usbd_cdc_if.c myAPP_device_init.c myAPP_system.c myAPP_motor.c
  group Drivers/PY32F0xx_HAL_Driver
    ../Drivers/PY32F4xx_HAL_Driver/Src/: py32f4xx_hal.c py32f4xx_hal_adc.c py32f4xx_hal_adc_ex.c py32f4xx_hal_cortex.c py32f4xx_hal_dma.c py32f4xx_hal_exti.c py32f4xx_hal_flash.c py32f4xx_hal_gpio.c py32f4xx_hal_i2c.c py32f4xx_hal_pwr.c py32f4xx_hal_pwr_ex.c py32f4xx_hal_rcc.c py32f4xx_hal_rcc_ex.c py32f4xx_hal_spi.c py32f4xx_hal_spi_ex.c py32f4xx_hal_tim.c py32f4xx_hal_tim_ex.c
  group CherryUSB
    ../Middlewares/Third_Party/CherryUSB/core/: usbd_core.c
    ../Middlewares/Third_Party/CherryUSB/port/: usb_dc_py32.c
    ../Middlewares/Third_Party/CherryUSB/class/cdc/: usbd_cdc.c
  group ltx
    ../ltx/src/: ltx.c
    ../ltx/components/app/: ltx_app.c
    ../ltx/components/debug/: ltx_cmd.c ltx_param.c
    ../ltx/components/event_group/: ltx_event_group.c
    ../ltx/components/lock/: ltx_lock.c
    ../ltx/components/log/: ltx_log.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../ltx/components/script/: ltx_script.c
software components: CMSIS:CORE 6.1.1
